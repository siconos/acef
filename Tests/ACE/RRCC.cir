RRCC

VIN	1	0	AC	1	SIN(0	1	10)

R1 0 1 10.0
R2 0 2 10.0

C1 2 1 22u
C2 0 2 22u
